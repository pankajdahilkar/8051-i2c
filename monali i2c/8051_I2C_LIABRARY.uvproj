# Keil uVision project 8051_I2C_LIABRARY.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_I2C_LIABRARY +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: I2C.C delay.c main.c RTC.c serial.c lcd.c keypad.c
