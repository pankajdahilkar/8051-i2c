# Keil uVision project lcd_interface.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lcd_interface +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lcdmain.c main.c
